# Copyright (c) 2024 Bartosz Szostak
# This software is released under the MIT License.
# See the LICENSE file for more details.

PACKAGECONFIG:remove = "desktop-embeddings"
